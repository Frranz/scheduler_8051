# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: C517A-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(24000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: console.a51 proc_a.a51 proc_b.a51 scheduler.a51 init.a51 fkt_text.a51 OS1.inc OS2.inc OS3.inc
